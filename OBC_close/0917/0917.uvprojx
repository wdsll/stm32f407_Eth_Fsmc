# Keil uVision project 0917.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0917 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: .\APP\include;.\ARM\include;.\GD32_SYSTEM\Firmware\GD32F30x_standard_peripheral\Include;.\GD32_SYSTEM\Firmware\CMSIS\GD\GD32F30x\Include;.\HW\include;.\GD32_SYSTEM\Firmware\CMSIS;.\Simulink;.\Proto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./APP/src/: main.c LLC_soft_start.c temp_control.c charge_ctrl.c
    ./: Readme.txt LLC开环 bring_up模式.txt softstart_state_machine.txt 调试用例总表.txt pfc_state_machine_report.txt
    ./APP/include/: LLC_soft_start.h temp_control.h charge_ctrl.h
    ./APP/: llc_voltage_loop_design.txt 协议输出详细报告（CR Binary Protocol）.txt
  group FW
    ./GD32_SYSTEM/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group HW
    ./HW/src/: NVIC.c RCU.c Timer.c adc_dma.c pwm_llc.c pwm.c protect_exti.c Debug_printf.c pfc_control.c llc_control.c
    ./HW/include/: add_dma.h pwm_llc.h pwm.h protect_exti.h pfc_control.h debug_printf.h llc_control.h
  group ARM
    ./ARM/src/: gd32f30x_it.c systick.c
    ./GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ./GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Simulink
    ./Simulink/: defines.txt MCU_Control.c MCU_Control.h MCU_Control_private.h MCU_Control_types.h rtwtypes.h
  group Proto
    ./Proto/: llc_cr_proto.h llc_cr_proto.c llc_log_dump.c llc_log_dump.h llc_trace.c llc_trace.h
software components: CMSIS:CORE 5.6.0
