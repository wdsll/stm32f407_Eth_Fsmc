# Keil uVision project ATSAMD21G18A_Demo.uvprojx, settings and files
target ATSAMD21G18A_Demo (6190000)
  device: ATSAMD21G18A Microchip
  pack: Microchip.SAMD21_DFP.3.6.144
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ATSAMD21G18A_Demo
  AfterMake: fromelf --i32combined -o ".\Objects\ATSAMD21G18A_Demo.hex" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: _stack=__initial_sp
  c misc: -Wno-unknown-attributes -std=gnu11
  c include: .\include;..\firmware\src;..\firmware\src\config\samd21g18a;..\firmware\src\packs\ATSAMD21G18A_DFP;..\firmware\src\packs\CMSIS;..\firmware\src\packs\CMSIS\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\ATSAMD21G18A.sct
  group Application
    ../firmware/src/: main.c board.h
  group Harmony3 System
    ../firmware/src/config/samd21g18a/: exceptions.c initialization.c interrupts.c definitions.h device_vectors.h interrupts.h
  group Harmony3 Peripheral
    ../firmware/src/config/samd21g18a/peripheral/clock/: plib_clock.c
    ../firmware/src/config/samd21g18a/peripheral/evsys/: plib_evsys.c
    ../firmware/src/config/samd21g18a/peripheral/nvic/: plib_nvic.c
    ../firmware/src/config/samd21g18a/peripheral/nvmctrl/: plib_nvmctrl.c
    ../firmware/src/config/samd21g18a/peripheral/port/: plib_port.c
    ../firmware/src/config/samd21g18a/peripheral/sercom/usart/: plib_sercom0_usart.c
  group Startup (Keil)
    ./: startup_samd21_keil.c ATSAMD21G18A.sct
