# Keil uVision project 0824.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0824
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: .\App\include;.\ARM\include;.\GD32_SYSTEM\Firmware\GD32F30x_standard_peripheral\Include;.\GD32_SYSTEM\Firmware\CMSIS\GD\GD32F30x\Include;.\GD32_SYSTEM\Firmware\CMSIS;.\HW\include;.\App\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/src/: main.c debug_printf.c serial_console.c
    ./App/include/: debug_printf.h serial_console.h
    ./App/: 串口首次软硬联调说明.txt
  group FW
    ./GD32_SYSTEM/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group HW
    ./HW/src/: RCU.c adc_dma.c can_comm.c llc_control.c pfc_control.c protect.c pwm_llc.c
    ./HW/include/: RCU.h adc_dma.h can_comm.h llc_control.h pfc_control.h protect.h pwm_llc.h
  group ARM
    ./ARM/src/: gd32f30x_it.c systick.c
    ./GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ./GD32_SYSTEM/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
software components: CMSIS:CORE 5.6.0
